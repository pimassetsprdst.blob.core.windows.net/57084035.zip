Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-12-18T14:08:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 18 14:08:18 2020 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{51917897-E397-4B6E-B1C8-50E6DA71B54A}\ifc * Database version: 5507 * Database creation date: Fri Dec 18 14:08:18 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 18 14:08:18 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 18 14:08:18 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 87843073 Cover part for bath and shower faucet, 87843073(2021):87843073 Cover part for bath and shower faucet:468375
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 91.0078 mm; NominalHeight: 169.677 mm; NominalWidth: 149.973 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 87843073(2021); ConvergoRefNr: 0087-2012-0029-FI; ManufacturerName: Hansa; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 16/12/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: HD; Customs Code: 84819000; EAN Number: 4057304015410; EN Standard: EN 817; Noise Class: I (ISO 3822)
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.hansa.com/bim/87843073; Catalog Drawing URL: http://static.hansa.com/catdrw/87843073; Class: Trim Kit;Single lever; Dimension Drawing URL: http://static.hansa.com/dimdrw/87843073; FDV Document URL: http://www.hansa.com/datasheet/87843073/en/fdv; Group: Bath and shower faucets; Manufacturer: Hansa; Market: INT;DEU;AUT;BEL;NLD;FRA;CZE;SVK;ITA;ESP; Model: 87843073 Cover part for bath and shower faucet; Name_en: 87843073 Cover part for bath and shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 204 x 186 x 174; Package Weight: 1.4 kg; Product Code: 87843073; Product Datasheet: http://www.hansa.com/datasheet/87843073/en; Product Family: HANSASTELA; Product Image URL: http://static.hansa.com/image/87843073; Product URL: http://static.hansa.com/87843073; Technical DataSheet URL: http://www.hansa.com/datasheet/87843073/en; Type Name: 87843073 Cover part for bath and shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass; Diverter: TurnDiverter; Included: Square rosette;Sleeve; Installation and Maintenance: http://static.hansa.com/manual/87843073; Installation Type: Wall mounted for concealed unit; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: 40Cartridge; Spare Parts: http://static.hansa.com/sp/87843073
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 87843073(2021); Features: Trim Kit;Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 87843073; Name: 87843073 Cover part for bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 150x90x170 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 87843073; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 87843073 Cover part for bath and shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0545377 m2; Volume: 0.00231588 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 87843073(2021): 87843073 Cover part for bath and shower faucet; Family and Type: 87843073(2021): 87843073 Cover part for bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 87843073(2021): 87843073 Cover part for bath and shower faucet; Type Id: 87843073(2021): 87843073 Cover part for bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
